# IAR project HelloWorld_OS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S9B92 TexasInstruments LM3S9B92
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: $PROJ_DIR$; BSP; CFG; EXT; CPU\LuminaryMicro\DriverLib; CPU\LuminaryMicro\DriverLib\driverlib; CPU\LuminaryMicro\DriverLib\inc; uC-LIB; uC-CPU; uC-CPU\ARM-Cortex-M3\IAR; uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; uCOS-III\Source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld_OS.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group APP
    ./: app_cfg.h app_vect.c includes.h LED.c LED.h main.c os_app_hooks.c os_app_hooks.h os_cfg_app.h
  group BSP
    BSP/: LM3S9B92_Flash.icf
  group BSP/Headers
    BSP/: bsp.h bsp_display.h bsp_int.h bsp_motor.h bsp_sensors.h
  group BSP/Source
    BSP/: bsp.c bsp_display.c bsp_int.c bsp_motor.c bsp_sensors.c cpu_bsp.c
  group CFG
    uC-CPU/Cfg/Template/: cpu_cfg.h
    uC-LIB/Cfg/Template/: lib_cfg.h
    uCOS-III/Cfg/Template/: os_cfg.h
  group CPU/DriverLib
    CPU/LuminaryMicro/DriverLib/driverlib/: driverlib-cm3.a
  group CPU/Inc
    CPU/LuminaryMicro/DriverLib/inc/: asmdefs.h hw_adc.h hw_can.h hw_comp.h hw_epi.h hw_ethernet.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_i2s.h hw_ints.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h lm3s9b92.h
  group EXT
    EXT/: motor_lib.c motor_lib.h
  group uC/CPU/Headers
    uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
    uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/Source
    uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
    uC-CPU/: cpu_core.c
  group uC/LIB/Headers
    uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Source
    uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III/Headers
    uCOS-III/Source/: os.h os_type.h
    uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h
  group uC/OS-III/Source
    uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
